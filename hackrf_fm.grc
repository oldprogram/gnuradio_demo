options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
    thread_safe_setters: '1'
    title: top_block
  states: {}

blocks:
- name: audio_dec
  id: variable
  parameters:
    value: '10'
  states: {}
- name: bb_db
  id: variable_qtgui_range
  parameters:
    label: bb_db
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: cutoff
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Freq
    rangeType: int
    start: '80000'
    step: '10'
    stop: '110000'
    value: '93000'
  states: {}
- name: if_db
  id: variable_qtgui_range
  parameters:
    label: if_db
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '89'
  states: {}
- name: rf_db
  id: variable_qtgui_range
  parameters:
    label: rf_db
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '100'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: transition
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '10'
    widget: dial
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: audio_dec
    quad_rate: '500000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff
    decim: '1'
    gain: '1'
    samp_rate: '2000000'
    type: fir_filter_ccf
    width: transition
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: samp_rate
    fc: freq * 1000
    fftsize: '1024'
    grid: 'True'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: samp_rate
    fc: freq * 1000
    fftsize: '1024'
    grid: 'True'
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '190000'
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    fbw: '0.1'
    interp: '48'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    fbw: '0.1'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: bb_db
    freq0: freq * 1000
    gain0: rf_db
    gain_mode0: 'False'
    if_gain0: if_db
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0, '1']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0_0, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rtlsdr_source_0, '0', rational_resampler_xxx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
