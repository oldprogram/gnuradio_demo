options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
    thread_safe_setters: '1'
    title: top_block
  states: {}

blocks:
- name: bb_db
  id: variable_qtgui_range
  parameters:
    label: bb_db
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Freq
    rangeType: int
    start: '2400000000'
    step: '2000000'
    stop: '2480000000'
    value: '2440000000'
  states: {}
- name: if_db
  id: variable_qtgui_range
  parameters:
    label: if_db
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '89'
  states: {}
- name: rf_db
  id: variable_qtgui_range
  parameters:
    label: rf_db
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '100'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '80000000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    grid: 'True'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: bb_db
    freq0: freq
    gain0: rf_db
    gain_mode0: 'False'
    if_gain0: if_db
    sample_rate: '2000000'
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
