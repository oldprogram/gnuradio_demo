options:
  parameters:
    author: btfz
    category: Custom
    generate_options: qt_gui
    id: b210_double_receive
    output_language: python
    title: b210_double_receive
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '8000000'
  states: {}
- name: uhd_gain
  id: variable_qtgui_range
  parameters:
    comment: |-
      2,0,1,2
      uhd gain：(0~70)
    gui_hint: 2,0,1,2
    label: GAIN
    rangeType: int
    start: '0'
    step: '1'
    stop: '70'
    value: '35'
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters:
    comment: 提取复数的相位角
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: complex
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '4000'
    scale: 1/1000
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '4000'
    scale: 1/1000
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    comment: |-
      复数共轭相乘
      Result = (A1*A2) e^{j(\phi_1 - \phi_2)}
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: 180/math.pi
    type: float
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      - 不能 1 发 2 收，或者 2 发 1 收；只能 2 发或 2 收 或 2 发 2 收；
      - UHD 模块支持配置多个通道，对于发送，每个通道只能选 TX/RX 天线
                                                        对于接收，每个通道只能选择 RX2 或 TX/RX 天线（RX1 报错）
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: uhd_usrp_source_0_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    center_freq0: freq
    center_freq1: freq
    gain0: uhd_gain
    gain1: uhd_gain
    nchan: '2'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_complex_to_arg_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_divide_xx_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_moving_average_xx_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_moving_average_xx_0_0, '0', blocks_divide_xx_0, '1']
- [blocks_multiply_conjugate_cc_0, '0', blocks_complex_to_arg_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_moving_average_xx_0_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_moving_average_xx_0, '0']
- [uhd_usrp_source_0_0_0, '0', blocks_divide_xx_0, '0']
- [uhd_usrp_source_0_0_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [uhd_usrp_source_0_0_0, '0', qtgui_time_sink_x_0, '0']
- [uhd_usrp_source_0_0_0, '1', blocks_multiply_conjugate_cc_0, '1']
- [uhd_usrp_source_0_0_0, '1', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
