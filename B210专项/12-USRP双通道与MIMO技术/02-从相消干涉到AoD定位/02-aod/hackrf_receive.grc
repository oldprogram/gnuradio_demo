options:
  parameters:
    author: btfz
    generate_options: qt_gui
    id: hackrf_receive
    output_language: python
    title: hackrf_receive
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 2.0e9
  states: {}
- name: rx_gain_bb
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,2
    rangeType: int
    start: '0'
    step: '2'
    stop: '62'
    value: '36'
  states: {}
- name: rx_gain_if
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    rangeType: int
    start: '0'
    step: '8'
    stop: '40'
    value: '24'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1024000'
  states: {}
- name: vec_len
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1000'
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '4000'
    scale: 1/1000
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class aod_diff_finder(gr.sync_block):
          def __init__(self, samp_rate=2e6, scan_freq=10.0, diff_delay=1000):
              gr.sync_block.__init__(self,
                  name='AoD Diff Index Finder',
                  in_sig=[np.float32],
                  out_sig=[np.float32])
              
              self.samp_rate = samp_rate
              self.scan_period = int(samp_rate / scan_freq)
              self.diff_delay = diff_delay
              # 窗口需要包含扫描周期、差分延迟以及冗余
              self.window_size = int(self.scan_period + self.diff_delay + 2000)
              
              self.data_buffer = []
              self.n_items_read = 0
              self.aod = 0

          def work(self, input_items, output_items):
              in_pwr = input_items[0]
              out_pwr = output_items[0]
              
              # 将计算出的 AoD 输出到流中，方便 QT GUI Display
              out_pwr[:] = [self.aod] * len(out_pwr)
              
              for i in range(len(in_pwr)):
                  self.data_buffer.append(in_pwr[i])
                  
                  if len(self.data_buffer) >= self.window_size:
                      buf_np = np.array(self.data_buffer)
                      
                      # --- 核心修改：差分逻辑 ---
                      # 计算 buf_np[i + delay] - buf_np[i]
                      # 这会产生一个长度为 (len - delay) 的向量
                      diff_buf = buf_np[self.diff_delay:] - buf_np[:-self.diff_delay]
                      
                      # 1. 寻找差分最大值索引 -> 对应同步脉冲的陡峭上升沿
                      max_diff_rel_idx = np.argmax(diff_buf)
                      
                      # 2. 在原始 buffer 中寻找最小值索引 -> 对应相消干涉谷底
                      # 注意：为了公平比较，在同样的范围内搜索
                      min_rel_idx = np.argmin(buf_np)
                      
                      # 换算 AoD 角度
                      # idx_diff 是“静默点”相对于“同步起点”的偏移
                      idx_diff = min_rel_idx - max_diff_rel_idx
                      aod_val = (idx_diff / self.scan_period) * 360
                      
                      # 归一化角度到 0-360 度
                      self.aod = aod_val % 360

                      # 打印调试信息
                      if self.n_items_read % (self.scan_period * 2) < len(in_pwr):
                          print(f"--- 差分检测成功 ---")
                          print(f"脉冲上升沿索引: {max_diff_rel_idx}")
                          print(f"静默点索引: {min_rel_idx}")
                          print(f"AoD 角度: {self.aod:.2f}°")

                      # 弹出旧数据：移除一个扫描周期的长度
                      self.data_buffer = self.data_buffer[self.scan_period:]
                  
              self.n_items_read += len(in_pwr)
              return len(out_pwr)
    diff_delay: '1000'
    samp_rate: samp_rate
    scan_freq: '10'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"hackrf=0"'
    bb_gain0: rx_gain_bb
    freq0: freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: rx_gain_if
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,0,1,1
    name: '"原始数据"'
    type: complex
  states: {}
- name: qtgui_number_sink_2
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '2'
    min: '0'
    name: '"AoD 角度"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,1,1,1
    name: '"原始数据"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: '"mag^2"'
    label2: '"avg"'
    label3: '"diff"'
    name: '"mag^2"'
    nconnections: '3'
    size: '1024000'
    srate: samp_rate
    type: float
    ymax: '4'
    ymin: '-4'
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_complex_to_mag_squared_1, '0']
- [blocks_complex_to_mag_squared_1, '0', blocks_moving_average_xx_0_0_0_0, '0']
- [blocks_complex_to_mag_squared_1, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_delay_0, '0', blocks_sub_xx_0, '1']
- [blocks_moving_average_xx_0_0_0_0, '0', blocks_delay_0, '0']
- [blocks_moving_average_xx_0_0_0_0, '0', blocks_sub_xx_0, '0']
- [blocks_moving_average_xx_0_0_0_0, '0', epy_block_0, '0']
- [blocks_moving_average_xx_0_0_0_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_sub_xx_0, '0', qtgui_time_sink_x_0_0, '2']
- [epy_block_0, '0', qtgui_number_sink_2, '0']
- [osmosdr_source_0, '0', analog_agc_xx_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
