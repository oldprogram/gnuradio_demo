options:
  parameters:
    author: btfz
    generate_options: qt_gui
    id: hackrf_receive
    output_language: python
    title: hackrf_receive
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 2.0e9
  states: {}
- name: rx_gain_bb
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,3
    rangeType: int
    start: '0'
    step: '2'
    stop: '62'
    value: '36'
  states: {}
- name: rx_gain_if
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,3
    rangeType: int
    start: '0'
    step: '8'
    stop: '40'
    value: '24'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1024000'
  states: {}
- name: vec_len
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"hackrf=0"'
    bb_gain0: rx_gain_bb
    freq0: freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: rx_gain_if
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,0,1,1
    name: '"原始数据"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,1,1,1
    name: '"原始数据"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,2,1,1
    type: complex
  states: {}

connections:
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_time_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
