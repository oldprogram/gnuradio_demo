options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
    thread_safe_setters: '1'
    title: top_block
  states: {}

blocks:
- name: audio_dec
  id: variable
  parameters:
    value: '10'
  states: {}
- name: cutoff
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    comment: 2,1,1,2
    gui_hint: 2,1,1,2
    label: Freq
    rangeType: int
    start: '80000'
    step: '10'
    stop: '110000'
    value: '93000'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    comment: 1,1,1,2
    gui_hint: 1,1,1,2
    rangeType: int
    start: '0'
    step: '1'
    stop: '70'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: transition
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    comment: 1,3,2,1
    gui_hint: 1,3,2,1
    label: Volume
    rangeType: int
    start: '0'
    step: '1'
    stop: '10'
    value: '1'
    widget: dial
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: audio_dec
    quad_rate: '500000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import numba

      @numba.jit(nopython=True)
      def numba_convolve(in0, kernel):
          return np.convolve(in0, kernel, mode='same')

      class GaussianFilter(gr.sync_block):
          def __init__(self, window_size=5, std_dev=1.0):
              gr.sync_block.__init__(
                  self,
                  name='Gaussian Filter',
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.window_size = window_size
              self.std_dev = std_dev
              self.gaussian_kernel = self.generate_gaussian_kernel()

          def generate_gaussian_kernel(self):
              x = np.arange(-(self.window_size // 2), self.window_size // 2 + 1)
              gaussian = np.exp(-(x ** 2) / (2 * self.std_dev ** 2))
              return gaussian / gaussian.sum()

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]
              if 0:
                  # 边界填充
                  pad_width = self.window_size // 2
                  padded_in0 = np.pad(in0, (pad_width, pad_width), mode='symmetric')
                  convolved = numba_convolve(padded_in0, self.gaussian_kernel)
                  out[:] = convolved[pad_width:pad_width + len(out)]
              else:
                  out[:] = in0
              return len(output_items[0])
    std_dev: '1'
    window_size: '5'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff
    decim: '1'
    gain: '1'
    samp_rate: '2000000'
    type: fir_filter_ccf
    width: transition
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '8000'
    decim: '1'
    gain: '1'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      https://wiki.gnuradio.org/index.php/USRP_Source

      gain                 |       |  volume
      freq                 |       |
      src_freq           |       | before_filter
      low_pass_freq  |        | after_filter
    note: USRP Source 介绍
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: samp_rate
    comment: 3,1,1,2
    fc: freq * 1000
    fftsize: '1024'
    grid: 'True'
    gui_hint: 3,1,1,2
    name: '"src_freq"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: samp_rate
    comment: 4,1,1,2
    fc: freq * 1000
    fftsize: '1024'
    grid: 'True'
    gui_hint: 4,1,1,2
    name: '"before&after low pass filter"'
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '48000'
    comment: 3,3,1,1
    fc: '0'
    fftsize: '1024'
    gui_hint: 3,3,1,1
    name: '"before filter"'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_1_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '48000'
    comment: 4,3,1,1
    fc: '0'
    fftsize: '1024'
    gui_hint: 4,3,1,1
    name: '"after filter"'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    fbw: '0.1'
    interp: '48'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    fbw: '0.1'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: freq * 1000
    gain0: gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [epy_block_0, '0', blocks_multiply_const_vxx_0, '0']
- [epy_block_0, '0', qtgui_waterfall_sink_x_1_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0, '1']
- [low_pass_filter_1, '0', epy_block_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_1, '0']
- [rational_resampler_xxx_0, '0', qtgui_waterfall_sink_x_1, '0']
- [rational_resampler_xxx_0_0, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', rational_resampler_xxx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
