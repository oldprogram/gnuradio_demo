options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: receive
    output_language: python
    title: receive
  states: {}

blocks:
- name: BB
  id: variable_qtgui_range
  parameters:
    comment: |-
      5,0,1,2
      基带：0～62（步长：2）
      osmocom 建议：15～30
      用在接收模式下
    gui_hint: 5,0,1,2
    label: BB
    rangeType: int
    start: '0'
    step: '2'
    stop: '62'
    value: '16'
  states: {}
- name: IF
  id: variable_qtgui_range
  parameters:
    comment: |-
      4,0,1,2
      中频：
      (0~47) <- 发送
      (0~40) step 8 接收
      osmocom 建议是 15～30
      在收发模式都有影响
    gui_hint: 4,0,1,2
    label: IF
    rangeType: int
    start: '0'
    step: '8'
    stop: '40'
    value: '16'
  states: {}
- name: bandwidth
  id: variable
  parameters:
    comment: |-
      QPSK 信号的带宽大约是符号速率的一倍。
      根据实际系统中的滤波器和其他因素，实际带宽可能会稍微大一些，
      但一般我们近似认为带宽为符号速率的 1 到 1.2 倍。
    value: symbol_rate*1.2
  states: {}
- name: bit_rate
  id: variable
  parameters:
    comment: 比特率（Bit Rate）：这是传输比特的速率，单位是 bits per second (bps)。
    value: 1024*180*8
  states: {}
- name: cutoff
  id: variable_qtgui_range
  parameters:
    comment: |-
      3,0,1,2
      设备的总 RF 增益
    gui_hint: 0,0,1,2
    label: cutoff
    rangeType: int
    start: '1'
    step: '1'
    stop: '5000'
    value: '1'
  states: {state: disabled}
- name: file_name
  id: variable
  parameters:
    comment: |-
      测试所用视频资源下载：
      https://sample-videos.com/index.php#sample-mp4-video
    value: '"a.mkv"'
  states: {}
- name: freq
  id: variable_qtgui_entry
  parameters:
    comment: 3,0,1,1
    gui_hint: 3,0,1,1
    label: Receive Freq
    type: real
    value: 2400e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    comment: |-
      2,0,1,2
      设备的总 RF 增益
    gui_hint: 2,0,1,2
    label: gain
    start: '0.5'
    step: '0.1'
    stop: '2'
    value: '1'
  states: {}
- name: mark_delay
  id: variable
  parameters:
    value: mark_delays[sps]
  states: {}
- name: mark_delays
  id: variable
  parameters:
    comment: |-
      Tag Marking Delay for 
      Corr Est block, indexed
      by sps.

      Found empirically.
    value: '[0, 0, 34, 56, 87, 119]'
  states: {}
- name: modulated_sync_word
  id: variable_modulate_vector
  parameters:
    data: preamble
    mod: rxmod
    taps: '[1]'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: offset
  id: variable_qtgui_chooser
  parameters:
    comment: 3,1,1,1
    gui_hint: 3,1,1,1
    label: Offset
    labels: '["-5MHz", "-600kHz", "0", "+600kHz", "+5MHz"]'
    num_opts: '0'
    options: '[-5000000, -600000, 0, 600000, 5000000]'
    type: int
    value: '0'
  states: {}
- name: output_file_name
  id: variable
  parameters:
    value: '"output_"+file_name'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: preamble
  id: variable
  parameters:
    comment: '[0xac, 0xdd, 0xa4, 0xe2, 0xf2, 0x8c, 0x20, 0xfc]'
    value: '[0xac, 0xdd, 0xa4, 0xe2, 0xf2, 0x8c, 0x20, 0xfc]'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: random_data_num
  id: variable
  parameters:
    value: '48'
  states: {}
- name: ration
  id: variable
  parameters:
    value: '3'
  states: {}
- name: repet
  id: variable
  parameters:
    value: '3'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: rxmod
  id: variable
  parameters:
    value: digital.generic_mod(qpsk, False, sps, True, eb, False, False)
  states: {}
- name: samp_rate_after_constellation
  id: variable
  parameters:
    comment: |-
      通常情况下，为了满足奈奎斯特采样定理，采样率至少应该是符号速率的两倍。
      不过为了实际应用中的滤波和抗混叠，一般建议采样率为符号速率的 4 倍或更高。

      这里的星座调制采用 sps=4
    value: symbol_rate*sps
  states: {}
- name: samp_rate_after_interpolation
  id: variable
  parameters:
    comment: |-
      - 插值会成倍增加采样率
      - 插值不会影响带宽
    value: samp_rate_after_constellation*ration
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    comment: |-
      符号速率（Symbol Rate）：这是传输符号的速率，单位是 symbols per second。
      QPSK 每个符号表示 2 个比特。因此，符号速率可以通过如下公式计算：
      比特率/每符号比特数
    value: '737280.0'
  states: {}
- name: tx_freq
  id: variable
  parameters:
    value: freq+offset
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '0.001'
    type: cma
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1'
    max_gain: '2'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {state: disabled}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_by_tag_value_cc_0
  id: blocks_multiply_by_tag_value_cc
  parameters:
    comment: |-
      "amp_est" 是相关性估计器输出的估计
      振幅，估计振幅是块处理的时间窗口中
      任何一个样本的最大振幅（至少包括
      整个同步字）

      这个块：输出 = 输入 * 复数常数（复数常数从指定名称的标签中找到）
    tagname: '"amp_est"'
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: |-
      1字节输入，2字节输出
      一字节的低位2bit输出2字节
      LSB
    k: '2'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_corr_est_cc_0
  id: digital_corr_est_cc
  parameters:
    comment: 相关性估计器，下面是其同步字
    mark_delay: mark_delay
    maxoutbuf: '2000000'
    sps: sps
    symbols: modulated_sync_word
    threshold: '1'
    threshold_method: digital.THRESHOLD_DYNAMIC
  states: {state: disabled}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: '2'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1,2,3]'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: '0'
    loop_bw: 2*3.14/100.0
    max_dev: '0.5'
    osps: '2'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: phase_bw
    max_dev: '1.5'
    nfilters: '32'
    osps: '2'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {state: disabled}
- name: eb
  id: parameter
  parameters:
    label: Filter Rolloff
    type: eng_float
    value: '0.35'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import struct


      class blk_cal_error(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, preamble=[], random_data_num = 0, risks = 0.3, repet = 3, file_name = 'output.wav', debug = False):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='cal_error',   # will show up in GRC
                  in_sig=[np.int8],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.preamble = preamble
              self.preamble_bits = []
              self.preamble_bits_num = 0
              self.random_data_num = random_data_num
              self.total_num = 0
              self.total_error_num = 0
              self.datas_0 = []
              self.datas_1 = []
              self.repet = repet
              self.header_len = 2
              self.datas_one_frame_num = (len(preamble)+(self.header_len+random_data_num)*repet)*8
              self.debug = debug
              self.risks = risks # 比较头部信息时，出错容忍度(头部需要容错率，不然在有干扰时，头部都无法准确定位了）
              
              self.file_start = 0
              self.total_file_frame_num = 0
              self.file = open(file_name,"wb")
              
              self.file_info_bits = []
              self.file_info_len = 0
              self.file_info_crc = 0
              self.zero_wait = 0 # 基于 0 的行程编码
              
              for byte in self.preamble:
                  for i in range(7, -1, -1):
                      bit = (byte >> i) & 1
                      self.preamble_bits.append(float(bit))
              self.preamble_bits_num = len(self.preamble_bits)
              self.header_bits_num = self.header_len*repet*8
                    

          def find_preamble(self, datas):
              #print(datas[0:5])
              #print(self.preamble_bits[0:5])
              #print((datas[0]-0.5)*(self.preamble_bits[0]-0.5))

              # find preamble
              total_num = len(datas)
              #if total_num > self.preamble_bits_num*3:
              #    total_num = self.preamble_bits_num*3
                  
              for i in range(total_num - self.preamble_bits_num + 1):
                  error_num = 0
                  for j in range(self.preamble_bits_num):
                      if (datas[i+j]-0.5)*(self.preamble_bits[j]-0.5) < 0:
                          error_num = error_num + 1
                          if error_num >= self.preamble_bits_num*self.risks:
                              break
                              
                  if error_num <  self.preamble_bits_num*self.risks:
                      return i

              return -1
          
          def repet_dcode(self,datas,repet_num):
              int_datas = [int(bit) for bit in datas]
              datas_len = len(int_datas)
              if datas_len % repet_num != 0:#数据不对，不是整数倍
                  print("数据长度不对!!!")
                  exit(0)
              else:
                  o_datas_len = int(datas_len/repet_num)
                  o_datas = [0]*o_datas_len
                  for idx in range(o_datas_len):
                      zero_num = 0
                      for x in range(repet_num):
                          if int_datas[o_datas_len*x+idx] == 0:
                              zero_num += 1
                      if repet_num >= 2*zero_num:
                          o_datas[idx] = 1
                  return o_datas
                          
          def write_real_data_into_file(self, real_data_array):
              int_datas = [int(bit) for bit in real_data_array]
              int_datas_num = len(int_datas)
              #print("int_datas_num",int_datas_num)
              if int_datas_num != 0:
                  byte_data = bytearray()
                  for i in range(0,int_datas_num,8):
                      byte_value = 0
                      for j in range(8):
                          if i+j < int_datas_num:
                              byte_value <<= 1
                              byte_value |= (int_datas[i+j] & 0xFF) 
                      if byte_value == 0 and self.zero_wait == 0:
                          self.zero_wait = 1
                      elif byte_value == 0 and self.zero_wait == 1:
                          byte_data.append(0x00)
                          self.zero_wait = 0
                      elif byte_value != 0 and self.zero_wait == 0:
                          byte_data.append(byte_value)
                      elif byte_value != 0 and self.zero_wait == 1:
                          byte_data.extend([0]*byte_value)
                          self.zero_wait = 0
                          
                  self.file.write(byte_data)
                  self.file.flush()    
                  
          def cal_error(self):
              total0_num = len(self.datas_0)
              
              # find preamble
              index_0 = self.find_preamble(self.datas_0)
              
              
              if index_0 == -1 and total0_num > 4096:
              	self.datas_0 = []
              	print(index_0,total0_num,'\n')
                      
              # have at least one frame
              if index_0 != -1:
                  if index_0 + self.datas_one_frame_num <= total0_num:                
                      header0 = self.repet_dcode(self.datas_0[index_0+self.preamble_bits_num:index_0+self.preamble_bits_num+self.header_bits_num],self.repet)
                      header_bits0 = ''.join(str(int(bit)) for bit in header0)
                      index0_sn = int(header_bits0, 2)
                      if self.debug == True:
                          print('sn:%d, in0:%d, %d, rand_datas = %d (bits)' %(index0_sn, index_0, total0_num, self.random_data_num*8))
                      
                      # 缓存文件信息 sn == 1 的包的前 8 字节
                      if self.file_start == 1 and index0_sn == 1:
                          self.file_info_bits = np.append(self.file_info_bits,self.datas_0[index_0+self.preamble_bits_num+self.header_bits_num:index_0+self.preamble_bits_num+self.header_bits_num+8*8])
                      if self.file_start == 1 and index0_sn == 2:
                          file_info = self.repet_dcode(self.file_info_bits,int(len(self.file_info_bits)/(8*8)))
                          file_info_len_bits = ''.join(str(int(bit)) for bit in file_info[0:32])
                          file_info_crc_bits = ''.join(str(int(bit)) for bit in file_info[32:64])
                          print(file_info_len_bits,file_info_crc_bits)
                          self.file_info_len = int(file_info_len_bits, 2)
                          self.file_info_crc = int(file_info_crc_bits, 2)
                          
                      
                      if (self.file_start != 0 and index0_sn == self.file_start + 1) or (index0_sn > 2 and self.file_info_len != 0):
                          # 有些情况下会断层丢几包，此时直接补 0（这样接收文件至少看起来还正常一点）
                          if index0_sn > self.file_start + 1:
                              lose = index0_sn - self.file_start - 1
                              if lose > 0 and lose < 3:
                                  for x in range(lose):
                                      self.total_file_frame_num += 1
                                      self.write_real_data_into_file([0]*self.random_data_num)
                                      
                          self.total_file_frame_num += 1
                          self.write_real_data_into_file(self.repet_dcode(self.datas_0[index_0+self.preamble_bits_num+self.header_bits_num:index_0+self.datas_one_frame_num],self.repet))
                          #print("total_file_frame_num:%d, file_data_len:%d, file_data_crc:0x%x" %(self.total_file_frame_num,self.file_info_len,self.file_info_crc))
                              
                      self.file_start = index0_sn

                      
                      # cut the one frame
                      self.datas_0 = self.datas_0[index_0+self.datas_one_frame_num:]
                    
                      self.cal_error()
                  
          def work(self, input_items, output_items):
              """example: multiply with constant"""
              o_len = len(output_items[0])
              
              # buffer the input datas
              self.datas_0 = np.append(self.datas_0,input_items[0])
              
              self.cal_error()
              
              if self.file_info_len != 0:
                  output_items[0][:] = [int(((self.total_file_frame_num*self.random_data_num)*100)/self.file_info_len)*1.0]*o_len
                  #print(o_len,self.total_file_frame_num,self.total_file_frame_num*self.random_data_num,self.file_info_len,self.file_start)
              else:
                  output_items[0][:] = [0.0]*o_len
              
                  
              return len(output_items[0])
    debug: 'True'
    file_name: output_file_name
    preamble: preamble
    random_data_num: random_data_num
    repet: repet
    risks: '0.1'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff*1000
    decim: '1'
    gain: '1'
    samp_rate: samp_rate_after_interpolation
    type: fir_filter_ccf
    width: bandwidth
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"hackrf=1"'
    bb_gain0: BB
    bw0: bandwidth
    freq0: int(freq)
    gain0: '0'
    gain_mode0: 'True'
    if_gain0: IF
    sample_rate: samp_rate_after_interpolation
    sync: none
    type: fc32
  states: {}
- name: process
  id: qtgui_number_sink
  parameters:
    color1: ("blue", "red")
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '100'
    min: '0'
    name: ''
    type: float
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    comment: 7,4,1,2
    gui_hint: 7,4,1,2
    legend: 'False'
    name: '"科斯塔斯环路"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    comment: 6,2,1,2
    gui_hint: 6,2,1,2
    legend: 'False'
    name: '"下采样"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    comment: 6,0,1,2
    gui_hint: 6,0,1,2
    legend: 'False'
    name: '"原始数据"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0_1
  id: qtgui_const_sink_x
  parameters:
    comment: 6,4,1,2
    gui_hint: 6,4,1,2
    legend: 'False'
    name: '"低通滤波器"'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0_1_0
  id: qtgui_const_sink_x
  parameters:
    comment: 7,0,1,2
    gui_hint: 7,0,1,2
    legend: 'False'
    name: '"符号同步"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0_1_0_0
  id: qtgui_const_sink_x
  parameters:
    comment: 6,4,1,2
    gui_hint: 6,4,1,2
    legend: 'False'
    name: '"增益"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0_2
  id: qtgui_const_sink_x
  parameters:
    comment: 7,2,1,2
    gui_hint: 7,2,1,2
    legend: 'False'
    name: '"线性均衡"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0_2_0
  id: qtgui_const_sink_x
  parameters:
    comment: 7,0,1,2
    gui_hint: 7,0,1,2
    legend: 'False'
    name: '"多项时钟同步"'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_1
  id: qtgui_const_sink_x
  parameters:
    comment: 6,4,1,2
    gui_hint: 6,4,1,2
    legend: 'False'
    name: '"相关性误差"'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    color2: red
    gui_hint: 4,2,2,4
    samp_per_symbol: '1'
    size: '1024'
    srate: samp_rate_after_interpolation
    type: complex
    ymax: '2.5'
    ymin: '-2.5'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: bandwidth
    comment: 6,0,1,2
    fc: int(freq)
    fftsize: '1024'
    gui_hint: 2,2,2,4
    legend: 'False'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    comment: |-
      图像显示采样率 100KHz，则一个符号占 10us
      1,0,1,2
    gui_hint: 1,0,1,2
    label1: '|corr|^2'
    label2: Re{corr}
    label3: Im{corr}
    name: ''
    nconnections: '3'
    size: 1024*2
    srate: 20000000/ration
    tr_level: '0'
    type: float
    ymax: '100'
    ymin: '-100'
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: ration
    interp: '1'
    type: ccc
  states: {}
- name: sps_0
  id: parameter
  parameters:
    label: Samples per Symbol
    type: eng_float
    value: '2'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: rx_data
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: t1
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: t2
  states: {}
- name: virtual_sink_1_0_0
  id: virtual_sink
  parameters:
    stream_id: t3
  states: {state: disabled}
- name: virtual_sink_1_0_0_0
  id: virtual_sink
  parameters:
    stream_id: t4
  states: {}
- name: virtual_sink_1_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: t5
  states: {}
- name: virtual_sink_1_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: t6
  states: {}
- name: virtual_sink_1_0_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: t7
  states: {state: disabled}
- name: virtual_sink_1_0_0_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: t8
  states: {}
- name: virtual_sink_1_0_0_0_1
  id: virtual_sink
  parameters:
    stream_id: t9
  states: {state: disabled}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: rx_data
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: t1
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: t2
  states: {}
- name: virtual_source_1_1
  id: virtual_source
  parameters:
    stream_id: t3
  states: {state: disabled}
- name: virtual_source_1_1_0
  id: virtual_source
  parameters:
    stream_id: t4
  states: {}
- name: virtual_source_1_2
  id: virtual_source
  parameters:
    stream_id: t5
  states: {}
- name: virtual_source_1_2_0
  id: virtual_source
  parameters:
    stream_id: t6
  states: {}
- name: virtual_source_1_2_0_0
  id: virtual_source
  parameters:
    stream_id: t7
  states: {state: disabled}
- name: virtual_source_1_2_0_0_0
  id: virtual_source
  parameters:
    stream_id: t8
  states: {}
- name: virtual_source_1_2_1
  id: virtual_source
  parameters:
    stream_id: t9
  states: {state: disabled}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: t1
  states: {state: disabled}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    stream_id: t8
  states: {}
- name: virtual_source_2_1
  id: virtual_source
  parameters:
    stream_id: t8
  states: {state: disabled}
- name: virtual_source_2_2
  id: virtual_source
  parameters:
    stream_id: t2
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: t4
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:49201
    timeout: '100'
    type: complex
  states: {state: disabled}

connections:
- [analog_agc_xx_0, '0', virtual_sink_1_0_0_0_0_0_0_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_time_sink_x_1_0, '1']
- [blocks_complex_to_float_0, '1', qtgui_time_sink_x_1_0, '2']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_multiply_by_tag_value_cc_0, '0', virtual_sink_1_0_0_0_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', virtual_sink_1_0_0_0_0_0_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', epy_block_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_corr_est_cc_0, '0', blocks_multiply_by_tag_value_cc_0, '0']
- [digital_corr_est_cc_0, '1', blocks_complex_to_float_0, '0']
- [digital_corr_est_cc_0, '1', blocks_complex_to_mag_0, '0']
- [digital_costas_loop_cc_0, '0', virtual_sink_0, '0']
- [digital_costas_loop_cc_0, '0', virtual_sink_1_0_0_0_0_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0, '0']
- [digital_linear_equalizer_0, '0', virtual_sink_1_0_0_0_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', virtual_sink_1_0_0_0, '0']
- [epy_block_0, '0', process, '0']
- [low_pass_filter_0, '0', virtual_sink_1_0_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', rational_resampler_xxx_0, '0']
- [osmosdr_source_0, '0', virtual_sink_1, '0']
- [rational_resampler_xxx_0, '0', virtual_sink_1_0, '0']
- [virtual_source_0, '0', digital_constellation_decoder_cb_0, '0']
- [virtual_source_1, '0', qtgui_const_sink_x_0_0_0, '0']
- [virtual_source_1_0, '0', qtgui_const_sink_x_0_0, '0']
- [virtual_source_1_1, '0', qtgui_const_sink_x_0_0_1, '0']
- [virtual_source_1_1_0, '0', qtgui_const_sink_x_0_0_1_0, '0']
- [virtual_source_1_2, '0', qtgui_const_sink_x_0_0_2, '0']
- [virtual_source_1_2_0, '0', qtgui_const_sink_x_0, '0']
- [virtual_source_1_2_0, '0', qtgui_eye_sink_x_0, '0']
- [virtual_source_1_2_0_0, '0', qtgui_const_sink_x_0_1, '0']
- [virtual_source_1_2_0_0_0, '0', qtgui_const_sink_x_0_0_1_0_0, '0']
- [virtual_source_1_2_1, '0', qtgui_const_sink_x_0_0_2_0, '0']
- [virtual_source_2, '0', low_pass_filter_0, '0']
- [virtual_source_2_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [virtual_source_2_1, '0', digital_corr_est_cc_0, '0']
- [virtual_source_2_2, '0', analog_agc_xx_0, '0']
- [virtual_source_2_2, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_4, '0', digital_linear_equalizer_0, '0']
- [zeromq_sub_source_0, '0', qtgui_freq_sink_x_0, '0']
- [zeromq_sub_source_0, '0', rational_resampler_xxx_0, '0']
- [zeromq_sub_source_0, '0', virtual_sink_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
