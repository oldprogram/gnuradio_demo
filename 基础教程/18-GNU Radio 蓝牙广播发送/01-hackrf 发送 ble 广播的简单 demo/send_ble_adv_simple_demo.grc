options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: IF
  id: variable_qtgui_range
  parameters:
    comment: |-
      中频：(0~47) <- 发送
      osmocom 建议是 15～30
      在收发模式都有影响
    label: IF
    rangeType: int
    start: '0'
    step: '1'
    stop: '47'
    value: '16'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: tx_freq
  id: variable
  parameters:
    value: '2402000000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    begin_tag: pmt.intern("Begin")
    file: btle_ch37_iq_float32_welcom_msg.bin
    repeat: 'True'
    type: complex
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: hackrf=0
    bb_gain0: '0'
    freq0: tx_freq
    gain0: '0'
    if_gain0: IF
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: 1024*3
    srate: samp_rate
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', osmosdr_sink_0, '0']
- [blocks_file_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
