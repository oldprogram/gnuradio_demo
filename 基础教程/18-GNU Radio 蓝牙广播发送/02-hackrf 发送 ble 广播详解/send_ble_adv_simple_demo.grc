options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: IF
  id: variable_qtgui_range
  parameters:
    comment: |-
      中频：(0~47) <- 发送
      osmocom 建议是 15～30
      在收发模式都有影响
    label: IF
    rangeType: int
    start: '0'
    step: '1'
    stop: '47'
    value: '16'
  states: {}
- name: phy_datas
  id: variable
  parameters:
    value: (0xaa, 0xd6, 0xbe, 0x89, 0x8e, 0xcf, 0xf2, 0x51, 0xa4, 0x39, 0xa4, 0x64, 0xb1, 0x6c, 0x38, 0x42, 0x0c, 0xc4, 0x58, 0xba, 0x8f, 0x33, 0x8c, 0xdf, 0xbf, 0xf1, 0x27, 0x5b, 0xf7, 0xf6, 0xf7, 0x7f, 0x0b, 0x8e, 0x55, 0x99, 0x03, 0xc4, 0x8d, 0xbd, 0x15, 0xf9)
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: tx_freq
  id: variable
  parameters:
    value: '2402000000'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    begin_tag: pmt.intern("Begin")
    file: /home/btfz/Desktop/WORK_GNURADIO/gnuradio_demo/基础教程/18-GNU Radio 蓝牙广播发送/02-hackrf 发送 ble 广播详解/python/normalization_sample.bin
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (1, 3)
    type: byte
  states: {state: disabled}
- name: blocks_stream_mux_0_0
  id: blocks_stream_mux
  parameters:
    lengths: (15, len(phy_datas)*8*4, 15)
    num_inputs: '3'
    type: byte
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: len(phy_datas)*8*4
    type: byte
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: phy_datas
  states: {state: disabled}
- name: blocks_vector_source_x_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0, 0, 0)
  states: {state: disabled}
- name: blocks_vector_source_x_1_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[0]*15'
  states: {state: disabled}
- name: blocks_vector_source_x_1_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[0]*15'
  states: {state: disabled}
- name: digital_burst_shaper_xx_0
  id: digital_burst_shaper_xx
  parameters:
    insert_phasing: 'False'
    length_tag_name: '"packet_len"'
    post_padding: '15'
    pre_padding: '15'
    type: float
    window: ([])
  states: {state: disabled}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: (-1,1)
  states: {state: disabled}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: hackrf=0
    bb_gain0: '0'
    freq0: tx_freq
    gain0: '0'
    if_gain0: IF
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: 1024*3
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: (len(phy_datas)*8*4+15*2)*3
    srate: samp_rate
    type: float
  states: {state: disabled}

connections:
- [blocks_char_to_float_0, '0', digital_burst_shaper_xx_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_file_source_0, '0', osmosdr_sink_0, '0']
- [blocks_file_source_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_stream_mux_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_stream_mux_0_0, '0', blocks_char_to_float_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_stream_mux_0_0, '1']
- [blocks_unpack_k_bits_bb_0, '0', digital_map_bb_0, '0']
- [blocks_vector_source_x_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_vector_source_x_1, '0', blocks_stream_mux_0, '1']
- [blocks_vector_source_x_1_0, '0', blocks_stream_mux_0_0, '0']
- [blocks_vector_source_x_1_0_0, '0', blocks_stream_mux_0_0, '2']
- [digital_burst_shaper_xx_0, '0', qtgui_time_sink_x_1, '0']
- [digital_map_bb_0, '0', blocks_stream_mux_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
