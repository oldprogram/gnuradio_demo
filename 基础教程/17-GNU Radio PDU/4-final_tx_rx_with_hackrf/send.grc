options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: send
    output_language: python
    title: send
  states: {}

blocks:
- name: IF
  id: variable_qtgui_range
  parameters:
    comment: |-
      2,0,1,2
      中频：(0~47) <- 发送
      osmocom 建议是 15～30
      在收发模式都有影响
    gui_hint: 2,0,1,2
    label: IF
    rangeType: int
    start: '0'
    step: '1'
    stop: '47'
    value: '16'
  states: {}
- name: bandwidth
  id: variable
  parameters:
    comment: |-
      QPSK 信号的带宽大约是符号速率的一倍。
      根据实际系统中的滤波器和其他因素，实际带宽可能会稍微大一些，
      但一般我们近似认为带宽为符号速率的 1 到 1.2 倍。
    value: symbol_rate*1.2
  states: {}
- name: bit_rate
  id: variable
  parameters:
    comment: 比特率（Bit Rate）：这是传输比特的速率，单位是 bits per second (bps)。
    value: 1024*180*8
  states: {}
- name: button_msg
  id: variable_qtgui_toggle_button_msg
  parameters:
    comment: 2,3,2,1
    gui_hint: 2,3,2,1
    initPressed: 'False'
    label: '"调试/发送文件"'
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: file_name
  id: variable
  parameters:
    comment: |-
      测试所用视频资源下载：
      https://sample-videos.com/index.php#sample-mp4-video
    value: '"a.mkv"'
  states: {}
- name: freq
  id: variable_qtgui_entry
  parameters:
    comment: 1,0,1,1
    gui_hint: 1,0,1,1
    label: Receive Freq
    type: real
    value: 2400e6
  states: {}
- name: offset
  id: variable_qtgui_chooser
  parameters:
    comment: 1,1,1,1
    gui_hint: 1,1,1,1
    label: Offset
    labels: '["-5MHz", "-600kHz", "0", "+600kHz", "+5MHz"]'
    num_opts: '0'
    options: '[-5000000, -600000, 0, 600000, 5000000]'
    type: int
    value: '0'
  states: {}
- name: one_frame_data
  id: variable
  parameters:
    value: len(preamble)+(2+random_data_num)*repet
  states: {}
- name: preamble
  id: variable
  parameters:
    comment: '[0xac, 0xdd, 0xa4, 0xe2, 0xf2, 0x8c, 0x20, 0xfc]'
    value: '[0xac, 0xdd, 0xa4, 0xe2, 0xf2, 0x8c, 0x20, 0xfc]'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: random_data_num
  id: variable
  parameters:
    value: '48'
  states: {}
- name: ration
  id: variable
  parameters:
    value: '3'
  states: {}
- name: repet
  id: variable
  parameters:
    value: '3'
  states: {}
- name: samp_rate_after_constellation
  id: variable
  parameters:
    comment: |-
      通常情况下，为了满足奈奎斯特采样定理，采样率至少应该是符号速率的两倍。
      不过为了实际应用中的滤波和抗混叠，一般建议采样率为符号速率的 4 倍或更高。

      这里的星座调制采用 sps=4
    value: symbol_rate*sps
  states: {}
- name: samp_rate_after_interpolation
  id: variable
  parameters:
    comment: |-
      - 插值会成倍增加采样率
      - 插值不会影响带宽
    value: samp_rate_after_constellation*ration
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    comment: |-
      符号速率（Symbol Rate）：这是传输符号的速率，单位是 symbols per second。
      QPSK 每个符号表示 2 个比特。因此，符号速率可以通过如下公式计算：
      比特率/每符号比特数
    value: bit_rate/2
  states: {}
- name: tx_freq
  id: variable
  parameters:
    value: freq+offset
  states: {}
- name: blocks_char_to_float_0_0_1_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate_after_constellation
    type: complex
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import time
      import zlib
      import pmt


      class epb_blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, file_path="a.mkv", data_length=20, preamble=[], n_zero_frame=3, repet=3):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                      self,
                      name='MyFileSink',   # will show up in GRC
                      in_sig=None,
                      out_sig=[np.uint8]
                      )
                      
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.in_port_name = 'test/transfer'
              self.message_port_register_in(pmt.intern(self.in_port_name))
              self.set_msg_handler(pmt.intern(self.in_port_name), self.handle_msg)
              
              self.file_data = []
              self.test_data = []
              self.current_position = 0
              self.test_current_position = 0
              self.test = 1
              
              # 构建调试数据帧
              self.test_data.extend([0]*5)
              self.test_data.extend(preamble)
              self.test_data.extend([0, 0]*repet)
              #self.test_data.extend([0x78]*data_length)
              self.test_data.extend([x for x in range(data_length)]*repet)
              self.test_data.extend([0]*5)
              self.test_data_len = len(self.test_data)
              
              # 构建发送文件数据
              with open(file_path, 'rb') as file:
                  file_data = file.read()
                  file_data_len = len(file_data)
                  file_data_crc32 = zlib.crc32(file_data) & 0xFFFFFFFF
                  file_data_pos = 0
                  
                  # 将 file_data 实施 00 的行程编码（将连续 n 个 0变为：0+连续0的个数（当个数 > 0xff）
                  tmp_data = []
                  zero_num = 0
                  for d in file_data:
                      if d == 0:
                          zero_num += 1
                          if zero_num > 0xff:
                              tmp_data.append(0x00)
                              tmp_data.append(0xff)
                              zero_num -= 0xff
                      else:
                          if zero_num == 0:
                              tmp_data.append(d) 
                          else:
                              tmp_data.append(0)
                              tmp_data.append(zero_num)
                              tmp_data.append(d) 
                              zero_num = 0

                  tmp_data_len = len(tmp_data)    
                  tmp_data_crc32 =  zlib.crc32(bytes(tmp_data)) & 0xFFFFFFFF

                  tmp_data_pos = 0

                  frame_num = 1
                  # 填充头部信息（文件头部）
                  # n_zero_frame
                  # 前置空帧，用于让接收锁定文件起始位置
                  for idx in range(n_zero_frame):
                      self.file_data.extend(preamble)
                      self.file_data.extend([(frame_num>>8) & 0xFF, (frame_num>>0) & 0xFF]*repet)
                      self.file_data.extend([(tmp_data_len>>24) & 0xFF, (tmp_data_len>>16) & 0xFF, (tmp_data_len>>8) & 0xFF, (tmp_data_len>>0) & 0xFF, (tmp_data_crc32>>24) & 0xFF, (tmp_data_crc32>>16) & 0xFF, (tmp_data_crc32>>8) & 0xFF, (tmp_data_crc32>>0) & 0xFF])
                      self.file_data.extend([0x55]*(data_length*repet-8))

                  frame_num = 2
                  # n 个 frame
                  for idx in range(0,tmp_data_len,data_length):
                      #print("xx",idx)
                      left = tmp_data_len - idx
                      if left >= data_length:# 剩余足够一帧
                          self.file_data.extend(preamble)
                          self.file_data.extend([(frame_num>>8) & 0xFF, (frame_num>>0) & 0xFF]*repet)
                          #self.file_data.extend(np.frombuffer(tmp_data[idx:idx+data_length]*repet, dtype=np.uint8))
                          self.file_data.extend(tmp_data[idx:idx+data_length]*repet)
                          if frame_num == 2:
                              #for i in range(10-frame_num):
                              self.file_data.extend(preamble)
                              self.file_data.extend([(frame_num>>8) & 0xFF, (frame_num>>0) & 0xFF]*repet)
                              #self.file_data.extend(np.frombuffer(tmp_data[idx:idx+data_length]*repet, dtype=np.uint8))
                              self.file_data.extend(tmp_data[idx:idx+data_length]*repet)
                      else:# 还剩，补 0 形成 1 frame
                          self.file_data.extend(preamble)
                          self.file_data.extend([(frame_num>>8) & 0xFF, (frame_num>>0) & 0xFF]*repet)
                          #self.file_data.extend(np.frombuffer(tmp_data[idx:idx+left]*repet, dtype=np.uint8))
                          self.file_data.extend(tmp_data[idx:idx+left]*repet)
                          self.file_data.extend([0]*((data_length-left)*repet))
                                      
                      frame_num += 1
                      
                  self.file_data_len = len(self.file_data)
                  print("total file data len:%d->%d, pre_file_frame_num:%d, frame num:%d" %(tmp_data_len, self.file_data_len, n_zero_frame, frame_num))

          def handle_msg(self, msg):
              x = pmt.to_python(msg)[1]
              if x == 1:
                  self.test = 0
              else:
                  self.test = 1
              #print(pmt.to_python(msg)[1])
               
          def work(self, input_items, output_items):
              # Check if there is enough data left in the file
              o_len = len(output_items[0])
              #print(">>>>>",o_len)
              if self.test == 1:
                  for idx in range(0,o_len,self.test_data_len):
                      left = o_len - idx
                      if left >= self.test_data_len:
                          output_items[0][idx:idx+self.test_data_len] = (self.test_data*2)[self.test_current_position:self.test_current_position+self.test_data_len]
                          self.test_current_position += self.test_data_len
                          self.test_current_position %= self.test_data_len
                      else:
                          #print(left)
                          output_items[0][idx:idx+left] = (self.test_data*2)[self.test_current_position:self.test_current_position+left]
                          self.test_current_position += left
                          self.test_current_position %= self.test_data_len
              else:
                  left = self.file_data_len - self.current_position
                  #print(o_len,left)
                  if left >= o_len:
                      output_items[0][0:o_len] = self.file_data[self.current_position:self.current_position+o_len]
                      self.current_position += o_len
                  elif left > 0:
                      output_items[0][0:left] = self.file_data[self.current_position:self.current_position+left]
                      output_items[0][left:] = [0]*(o_len-left)
                      self.current_position += left
                      self.test = 1
                  else:
                      self.test = 1
              
              return len(output_items[0]) 
    data_length: random_data_num
    file_path: file_name
    n_zero_frame: '5'
    preamble: preamble
    repet: repet
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"hackrf=0"'
    bb_gain0: '0'
    bw0: bandwidth
    freq0: int(tx_freq)
    gain0: '0'
    if_gain0: IF
    sample_rate: samp_rate_after_interpolation
    sync: none
    type: fc32
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    comment: 0,2,1,2
    gui_hint: 0,2,1,2
    size: int(one_frame_data*16*2.5)
    srate: samp_rate_after_constellation
    type: complex
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_1_1_0
  id: qtgui_time_sink_x
  parameters:
    comment: 0,0,1,2
    gui_hint: 0,0,1,2
    size: int(one_frame_data*2.5)
    srate: int(bit_rate/8)
    type: float
    update_time: '1'
    ymax: '200'
    ymin: '-200'
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    comment: 重复 n 倍
    decim: '1'
    interp: ration
    type: ccc
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:49201
    timeout: '100'
    type: complex
  states: {state: disabled}

connections:
- [blocks_char_to_float_0_0_1_0, '0', qtgui_time_sink_x_1_1_0, '0']
- [blocks_throttle2_1, '0', rational_resampler_xxx_0_0, '0']
- [button_msg, state, epy_block_1, test/transfer]
- [digital_constellation_modulator_0, '0', blocks_throttle2_1, '0']
- [digital_constellation_modulator_0, '0', qtgui_time_sink_x_1, '0']
- [epy_block_1, '0', blocks_char_to_float_0_0_1_0, '0']
- [epy_block_1, '0', digital_constellation_modulator_0, '0']
- [rational_resampler_xxx_0_0, '0', osmosdr_sink_0, '0']
- [rational_resampler_xxx_0_0, '0', zeromq_pub_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
