options:
  parameters:
    author: Josh Morman
    copyright: '2020'
    generate_options: qt_gui
    id: linear_equalizer_compare
    output_language: python
    title: Compare Linear Equalizers
  states: {}

blocks:
- name: alg
  id: variable_adaptive_algorithm
  parameters:
    comment: |-
      自适应算法：
      - 可选：LMS（最小均方）、NLMS  (归一化最小均方)、CMA （恒模盲均衡）
      - 星座对象：qpsk
      - 步长：gain
    cons: cons
    delta: '40'
    ffactor: '0.999'
    modulus: '4'
    step_size: gain
    type: lms
  states: {}
- name: cons
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: corr_calc
  id: variable
  parameters:
    value: corr_thresh/(corr_max*corr_max)
  states: {}
- name: corr_max
  id: variable
  parameters:
    value: numpy.abs(numpy.dot(modulated_sync_word,numpy.conj(modulated_sync_word)))
  states: {}
- name: corr_thresh
  id: variable_qtgui_range
  parameters:
    label: Absolute Corr Thresh (Mag Sq)
    start: '0.1'
    step: '1.0'
    stop: 5e6
    value: 1e6
  states: {}
- name: data
  id: variable
  parameters:
    comment: 4 个 0 + 100 个随机数
    value: '[0]*4+[random.getrandbits(8) for i in range(payload_size)]'
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '8'
    value: '0'
  states: {}
- name: eb
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: gain
  id: variable
  parameters:
    value: '.0001'
  states: {}
- name: modulated_sync_word
  id: variable
  parameters:
    comment: |-
      注意：由 Modulate Vector 生成的调制同步字
      有一些滤波瞬变，这里做一些偏移，从而到实际
      的想要的同步字。

      64bytes*8*sps(4)/2(qpsk,2bits/1byte) 
      = 1024 bytes
    value: modulated_sync_word_pre[86:(512+86)]
  states: {}
- name: modulated_sync_word_pre
  id: variable_modulate_vector
  parameters:
    comment: |-
      将两个 preamble 利用 rxmod 进行调制
      rxmod 是 python 函数方式的星座调制，基于 cons(qpsk)
    data: ' preamble+preamble'
    mod: rxmod
    taps: '[1]'
  states: {}
- name: num_plot_evm
  id: variable
  parameters:
    value: '8192'
  states: {}
- name: num_taps
  id: variable
  parameters:
    value: '64'
  states: {}
- name: payload_size
  id: variable
  parameters:
    value: '100'
  states: {}
- name: phase
  id: variable_qtgui_range
  parameters:
    label: phase
    start: '0.00'
    step: '.1'
    stop: '3.14'
    value: '0'
  states: {}
- name: preamble
  id: variable
  parameters:
    comment: 32 字节的 preamble
    value: '[0x27,0x2F,0x18,0x5D,0x5B,0x2A,0x3F,0x71,0x63,0x3C,0x17,0x0C,0x0A,0x41,0xD6,0x1F,0x4C,0x23,0x65,0x68,0xED,0x1C,0x77,0xA7,0x0E,0x0A,0x9E,0x47,0x82,0xA4,0x57,0x24,]'
  states: {}
- name: preamble_symbols
  id: variable
  parameters:
    value: helpers.map_symbols_to_constellation(helpers.unpack_values(preamble, 8, 2), cons)
  states: {}
- name: rxmod
  id: variable
  parameters:
    value: digital.generic_mod(cons, False, sps, True, eb, False, False)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: num_plot_evm
    type: float
  states: {}
- name: blocks_head_0_0
  id: blocks_head
  parameters:
    num_items: num_plot_evm
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: preamble+data
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: num_taps
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_1
  id: blocks_vector_to_stream
  parameters:
    num_items: num_taps
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.0'
    seed: '0'
    taps: (1.0 + 1.0j, 0,0,0,0.63-.22j, -.1+.07j)
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: cons
    differential: 'False'
    excess_bw: '0.35'
    samples_per_symbol: '4'
  states: {}
- name: digital_corr_est_cc_0
  id: digital_corr_est_cc
  parameters:
    comment: 相关性估计器
    mark_delay: '12'
    sps: sps
    symbols: modulated_sync_word
    threshold: corr_calc
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: alg
    num_taps: num_taps
    sps: '4'
    training_sequence: preamble_symbols
  states: {}
- name: digital_linear_equalizer_0_0
  id: digital_linear_equalizer
  parameters:
    alg: alg
    num_taps: num_taps
    sps: '4'
    training_sequence: '[]'
    training_start_tag: ''''''
  states: {}
- name: digital_meas_evm_cc_0
  id: digital_meas_evm_cc
  parameters:
    cons: cons
    meas_type: digital.evm_measurement_t.EVM_PERCENT
  states: {}
- name: digital_meas_evm_cc_0_0
  id: digital_meas_evm_cc
  parameters:
    cons: cons
    meas_type: digital.evm_measurement_t.EVM_PERCENT
  states: {}
- name: helpers
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph


      def unpack_values(values_in, bits_per_value, bits_per_symbol):   
          # verify that 8 is divisible by bits_per_symbol 
          m = bits_per_value / bits_per_symbol
          # print(m)
          mask = 2**(bits_per_symbol)-1
              
          if bits_per_value != m*bits_per_symbol:
              print("error - bits per symbols must fit nicely into bits_per_value bit values")
              return []
              
          num_values = len(values_in)
          # print(num_values)
          num_symbols = int(num_values*( m) )
          # print(num_symbols)
          cur_byte = 0
          cur_bit = 0
          out = []
          for i in range(num_symbols):
              s = (values_in[cur_byte] >> (bits_per_value-bits_per_symbol-cur_bit)) & mask
              out.append(s)
              cur_bit += bits_per_symbol
              
              if cur_bit >= bits_per_value:
                  cur_bit = 0
                  cur_byte += 1
                  
              # if cur_byte >= num_values:
                  # break;
                  
          return out
          
      def map_symbols_to_constellation(symbols, cons):
          # print("symbols:")
          # print(symbols)
          # print("points:")
          # print(cons.points())
          l = list(map(lambda x: cons.points()[x], symbols))
          # print("Training Symbols")
          # print(l)
          return l
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import random
  states: {}
- name: import_0_1
  id: import
  parameters:
    imports: from cmath import exp, pi
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      3.10.9.2 (Python 3.11.6)
      该流程图展示了各种 LMS 均衡器实现之间的差异：
      1) gr-equalizers LMS training sequence based（基于 LMS 训练序列）
      2) gr-equalizers LMS decision directed（基于 LMS 决策导向）

      修改算法对象以探索其他变体。
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 3,2,2,1
    label1: LMS - Training Sequence
    label2: LMS - Decision Directed
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 1,0
    size: '10240'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 2,0
    name: Correlation
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 3,0,1,2
    marker1: '0'
    marker2: '1'
    size: num_taps
    srate: samp_rate
    stemplot: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 4,0,1,2
    marker1: '0'
    marker2: '1'
    size: num_taps
    srate: samp_rate
    stemplot: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 5,0,1,3
    label1: LMS - Data Aided(辅助)
    label2: LMS - Decision Directed
    name: EVM Measurement
    nconnections: '2'
    size: num_plot_evm
    srate: samp_rate
    type: float
    ymax: '101'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: ce_sink
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: ce_sink
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_head_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_head_0_0, '0', qtgui_time_sink_x_2, '1']
- [blocks_throttle_0, '0', channels_channel_model_0, '0']
- [blocks_vector_source_x_0_0, '0', digital_constellation_modulator_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_vector_to_stream_0_1, '0', qtgui_time_sink_x_1_2, '0']
- [channels_channel_model_0, '0', digital_corr_est_cc_0, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle_0, '0']
- [digital_corr_est_cc_0, '0', qtgui_time_sink_x_0, '0']
- [digital_corr_est_cc_0, '0', virtual_sink_0, '0']
- [digital_corr_est_cc_0, '1', blocks_complex_to_mag_squared_0, '0']
- [digital_linear_equalizer_0, '0', digital_meas_evm_cc_0, '0']
- [digital_linear_equalizer_0, '0', qtgui_const_sink_x_0, '0']
- [digital_linear_equalizer_0, '1', blocks_vector_to_stream_0, '0']
- [digital_linear_equalizer_0_0, '0', digital_meas_evm_cc_0_0, '0']
- [digital_linear_equalizer_0_0, '0', qtgui_const_sink_x_0, '1']
- [digital_linear_equalizer_0_0, '1', blocks_vector_to_stream_0_1, '0']
- [digital_meas_evm_cc_0, '0', blocks_head_0, '0']
- [digital_meas_evm_cc_0_0, '0', blocks_head_0_0, '0']
- [virtual_source_0, '0', digital_linear_equalizer_0, '0']
- [virtual_source_0, '0', digital_linear_equalizer_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
