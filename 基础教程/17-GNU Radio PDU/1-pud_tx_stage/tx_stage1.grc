options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: tx_stage1
    output_language: python
  states: {}

blocks:
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.PMT_T
    period: '2000'
  states: {}
- name: digital_crc32_async_bb_1
  id: digital_crc32_async_bb
  parameters:
    check: 'False'
  states: {}
- name: pdu_random_pdu_0
  id: pdu_random_pdu
  parameters:
    length_modulo: '1'
    mask: '0xff'
    maxsize: '50'
    minsize: '15'
  states: {}

connections:
- [blocks_message_strobe_0, strobe, pdu_random_pdu_0, generate]
- [digital_crc32_async_bb_1, out, blocks_message_debug_0, print_pdu]
- [pdu_random_pdu_0, pdus, blocks_message_debug_0, print_pdu]
- [pdu_random_pdu_0, pdus, digital_crc32_async_bb_1, in]

metadata:
  file_format: 1
  grc_version: 3.10.8.0
