options:
  parameters:
    category: Custom
    description: Example of an OFDM Transmitter
    generate_options: qt_gui
    id: tx_ofdm
    output_language: python
    run_options: run
    title: tx_ofdm
  states: {}

blocks:
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: header_formatter
  id: variable
  parameters:
    value: digital.packet_header_ofdm(occupied_carriers, n_syms=1, len_tag_key=length_tag_key, frame_len_tag_key=length_tag_key, bits_per_header_sym=header_mod.bits_per_symbol(), bits_per_payload_sym=payload_mod.bits_per_symbol(), scramble_header=False)
  states: {}
- name: header_mod
  id: variable
  parameters:
    value: digital.constellation_bpsk()
  states: {}
- name: input_file_name
  id: variable
  parameters:
    value: '"test1.png"'
  states: {}
- name: input_file_size
  id: variable
  parameters:
    value: os.path.getsize(input_file_name)
  states: {}
- name: length_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: occupied_carriers
  id: variable
  parameters:
    value: (list(range(-26, -21)) + list(range(-20, -7)) + list(range(-6, 0)) + list(range(1, 7)) + list(range(8, 21)) + list(range(22, 27)),)
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '20'
  states: {}
- name: payload_mod
  id: variable
  parameters:
    value: digital.constellation_qpsk()
  states: {}
- name: pilot_carriers
  id: variable
  parameters:
    value: ((-21, -7, 7, 21,),)
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    value: ((1, 1, 1, -1,),)
  states: {}
- name: rolloff
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: sync_word1
  id: variable
  parameters:
    value: '[0., 0., 0., 0., 0., 0., 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 0., 0., 0., 0., 0.]'
  states: {}
- name: sync_word2
  id: variable
  parameters:
    value: '[0, 0, 0, 0, 0, 0, -1, -1, -1, -1, 1, 1, -1, -1, -1, 1, -1, 1, 1, 1, 1, 1, -1, -1, -1, -1, -1, 1, -1, -1, 1, -1, 0, 1, -1, 1, 1, 1, -1, 1, 1, 1, -1, 1, 1, 1, 1, -1, 1, -1, -1, -1, 1, -1, 1, -1, -1, -1, -1, 0, 0, 0, 0, 0] '
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: input_file_name
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: '*0.05'
    const: '0.05'
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    comment: |-
      100->400
      每个输入的1字节包含8bits 信息，每个输出的1字节包含2bits的信息
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: payload_mod.bits_per_symbol()
    len_tag_key: length_tag_key
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '10'
    type: byte
  states: {state: disabled}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (input_file_size,packet_len-input_file_size%packet_len)
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: length_tag_key
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    comment: 使用此块可以阻止标签传播
    propagate_tags: 'False'
    type: complex
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    comment: packet_len=448
    lengthtagname: length_tag_key
    ninputs: '2'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    comment: 节流阀，控制速度
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    comment: |-
      研究发现，发送 3840 = 96*40 ，
      实际最后 96 字节没成功
    repeat: 'False'
    type: byte
    vector: np.append(np.arange(0,packet_len*2,1) ,np.arange(0,packet_len*2,1))
  states: {state: disabled}
- name: blocks_vector_source_x_0_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: byte
    vector: np.arange(0,packet_len-input_file_size%packet_len,1)
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: header_mod.points()
  states: {}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: payload_mod.points()
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    comment: 96+4(CRC32) = 100
    lengthtagname: length_tag_key
    packed: 'True'
  states: {}
- name: digital_ofdm_carrier_allocator_cvc_0
  id: digital_ofdm_carrier_allocator_cvc
  parameters:
    fft_len: fft_len
    len_tag_key: length_tag_key
    occupied_carriers: occupied_carriers
    output_is_shifted: 'True'
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    sync_words: (sync_word1, sync_word2)
  states: {}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: fft_len//4
    input_size: fft_len
    rolloff: rolloff
    tagname: length_tag_key
  states: {}
- name: digital_packet_headergenerator_bb_0
  id: digital_packet_headergenerator_bb
  parameters:
    header_formatter: header_formatter.base()
    len_tag_key: length_tag_key
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      from gnuradio import digital


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""
          
          def __init__(self, 
                       vectorSize = 64, 
                       header_mod = digital.constellation_bpsk(), 
                       payload_mod = digital.constellation_qpsk(),
                       debug = False
                       ): # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Debug OFDM Block',   # will show up in GRC
                  in_sig=[(np.complex64,vectorSize)],
                  out_sig=[(np.complex64,vectorSize)]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.bpsk_points = header_mod.points()   # digital.constellation_bpsk().points()
              self.qpsk_points = payload_mod.points()  # digital.constellation_qpsk().points()
              self.debug = debug

          def work(self, input_items, output_items):
              output_items[0][:] = input_items[0] #port 0

              if self.debug == True:
                  BLACK = '\033[30m'
                  RED = '\033[31m'
                  GREEN = '\033[32m'
                  YELLOW = '\033[33m'
                  BLUE = '\033[34m'
                  MAGENTA = '\033[35m'
                  CYAN = '\033[36m'
                  WHITE = '\033[37m'
                  BG_BLACK = '\033[40m'
                  BG_RED = '\033[41m'
                  BG_GREEN = '\033[42m'
                  BG_YELLOW = '\033[43m'
                  BG_BLUE = '\033[44m'
                  BG_MAGENTA = '\033[45m'
                  BG_CYAN = '\033[46m'
                  BG_WHITE = '\033[47m'
                  RESET = '\033[0m'

                  """example: multiply with constant"""
                  print('\n-> every channel\'s datas:(%dx%d)' %(len(input_items[0][0]),len(input_items[0])))

                  for offset in range(len(input_items[0][0])):
                      if offset in [11,25,39,53]:
                          color = BG_BLACK+YELLOW
                          reset = RESET
                      elif offset in [0,1,2,3,4,5,59,60,61,62,63,32]:
                          color = BG_WHITE+RED
                          reset = RESET
                      else:
                          color = BG_GREEN+BLACK
                          reset = RESET
                 
                      print(color+"[%02d]->"  %(offset), end = ' ')
                      for vectorIndex in range(len(input_items[0])):
                          value = input_items[0][vectorIndex][offset]
                          if value in self.qpsk_points:
                              print('q%d' %(self.qpsk_points.index(value)), end = ' ')
                          elif value in self.bpsk_points:
                              print('b%d' %(self.bpsk_points.index(value)), end = ' ')
                          else:
                              if value.real < -1.4:
                                  print('x-', end = ' ')
                              elif value.real > 1.4:
                                  print('x+', end = ' ')
                              else:
                                  print('x0', end = ' ')
                      print(reset)
                  #print(len(input_items[0]),len(input_items[0][0]))

              return len(output_items[0])
    comment: debug for analy ofdm header
    debug: 'False'
    header_mod: header_mod
    payload_mod: payload_mod
    vectorSize: fft_len
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, length_tag_name='', debug=False):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                      self,
                      name='Debug Header Block',   # will show up in GRC
                      in_sig=[np.byte],
                      out_sig=[]
                      )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.length_tag_name = length_tag_name
              self.debug = debug
              

          def work(self, input_items, output_items):
              if self.debug == True:
                  """example: multiply with constant"""
                  # get all tags associated with input_items[0]
                  input_total_len = len(input_items[0])
                  input_offset = self.nitems_read(0)
                  tag_tuple = self.get_tags_in_window(0, 0, len(input_items[0]))
                  tag_num = len(tag_tuple)
                  one_tag_data_num = int(input_total_len/tag_num)

                  # loop through all 'detect' tags and store their relative offset
                  print("\none input, input_offset = %08d --> " %(input_offset))
                  for tag in tag_tuple:
                      if (pmt.to_python(tag.key) == self.length_tag_name):
                          tag_offset = tag.offset
                          tag_relative_offset = tag_offset - input_offset

                          '''
                          0-11 bits(12bits）： 数据包长度
                          12-23 bits(12bits)：标头编号（每次调用进行累加）
                          crc8 (8bits)
                          others (设置为0）
                          '''
                          print("data_lsb[%06d/%06d]=[" 
                                %(tag_relative_offset , input_total_len), end = '')
                          for index in range(one_tag_data_num):
                              print("%02X" %(input_items[0][tag_relative_offset+index]), end = ' ')
                              if index == 11: 
                                  print("len|", end = ' ')
                              elif index == 23:
                                  print("idx|", end = ' ')
                              elif index == 31:
                                  print("crc|", end = ' ')

                          print('|other]')

              return len(input_items[0])
    comment: debug for analy ofdm header
    debug: 'False'
    length_tag_name: length_tag_key
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'False'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import os
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: FFT Plot
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: Scope Plot
    label2: ''
    name: Scope Plot
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    comment: bpsk -> header=48
    gui_hint: (0,0)
    name: '"Pre-OFDM-header"'
    size: 48*3
    srate: '1'
    type: complex
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    comment: qpsk-> data=400
    gui_hint: (0,1)
    name: '"Pre-OFDM-data"'
    size: 400*3
    srate: '1'
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: Time Domain
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: Pre-OFDM
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: Tx Signal
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: Pre-OFDM
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: Time Domain
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: Tx Signal
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:49203
    comment: USRP sample rate = 768kHz
    timeout: '100'
    type: complex
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_file_source_0, '0', blocks_stream_mux_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_tag_gate_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [blocks_repeat_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_stream_mux_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_crc32_bb_0, '0']
- [blocks_tag_gate_0, '0', blocks_throttle2_0, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_0_0_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle2_0, '0', virtual_sink_1, '0']
- [blocks_vector_source_x_0, '0', blocks_repeat_0, '0']
- [blocks_vector_source_x_0_0_0, '0', blocks_stream_mux_0, '1']
- [digital_chunks_to_symbols_xx_0, '0', blocks_tagged_stream_mux_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', qtgui_time_sink_x_1, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [digital_chunks_to_symbols_xx_0_0, '0', qtgui_time_sink_x_1_0, '0']
- [digital_crc32_bb_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_crc32_bb_0, '0', digital_packet_headergenerator_bb_0, '0']
- [digital_ofdm_carrier_allocator_cvc_0, '0', epy_block_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', virtual_sink_0, '0']
- [digital_packet_headergenerator_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_packet_headergenerator_bb_0, '0', epy_block_1, '0']
- [epy_block_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', digital_ofdm_cyclic_prefixer_0, '0']
- [virtual_source_0_0_0, '0', digital_ofdm_carrier_allocator_cvc_0, '0']
- [virtual_source_0_0_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_1, '0', zeromq_pub_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
